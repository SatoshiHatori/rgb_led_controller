# Repository SatoshiHatori/rgb_led_controller

File README.md:

# RGB LED Controller

移動ロボットに載せる状態表示基板。CAN で受けた色を 24V コモンアノード RGB LED テープに出す。
マイコンは CH32V203K8T6、電源は 24V から生成する。

**状態: Rev B の設計完了。JLCPCB の部品実装向けにデータ作成済み (ERC/DRC 違反 0、未接続 0、回路図と基板の不一致 0)。発注、実機確認は未実施。**

要求、前提、未解決事項は [docs/requirements.md](docs/requirements.md)、設計判断は [docs/adr/](docs/adr/) で管理しています。

## ディレクトリ構成

```
docs/requirements.md   要求、設計上の前提、未解決事項
docs/adr/              設計判断の記録
firmware/              CH32V203 ファームウェア
hardware/              KiCad プロジェクト
├── docs/              README 掲載の画像
└── fabrication/       ガーバー、BOM、部品座標、ハーネス部品
```

## 仕様

| 項目 | 値 |
|---|---|
| 入力電圧 | DC/DC コンバータの 24V 出力 (モータ駆動回路とは別電源)。回路の許容範囲は約 13〜45V |
| 入力保護 | ヒューズ 10A (Littelfuse 0451010.MRL、表面実装)、TVS SMBJ45CA (クランプ最大 72.7V)、ローサイド N-FET 逆接保護 |
| 電源 | Q5 IRFR3910 (FET リニアプリレギュレータ) → CJ78L05 (5V) → AP7333 (3.3V) |
| マイコン | CH32V203K8T6 (8MHz 水晶、PLL なし) |
| CAN | ATA6561。既定 500kbit/s、低優先の ID 0x7D0。終端 120Ω は JP1 をはんだでつなぐと有効 |
| LED 出力 | ローサイド N-MOS × 3 (HYG080N10LS1C2、100V、4.5V 駆動で最大 13mΩ)、合計 5A の想定、PWM 1kHz |
| 端子 | JST VH (電源、LED)、JST PA (CAN)。いずれもロック付き |
| 拡張用パッド (未実装) | SWD 書き込み (J4)、デバッグ用 UART (J5)、空きポート 14 本 (J6) |
| 基板 | 51 × 42.6mm、2 層、厚さ 1.6mm、M3 取付穴 × 4 (四隅) |

## 回路図

PDF 版: [rgb_led_controller_schematic.pdf](hardware/rgb_led_controller_schematic.pdf)

## 接続

| 端子 | 型番 | ピン | 信号 |
|---|---|---|---|
| J1 | JST B2P-VH | 1 / 2 | +24V 入力 / GND 入力 |
| J2 | JST B4P-VH | 1 / 2 / 3 / 4 | +24V (共通) / R− / G− / B− |
| J3 | JST B03B-PASK | 1 / 2 / 3 | CANH / CANL / GND |
| J4 (未実装) | 1.27mm 4 ピン | 1 / 2 / 3 / 4 | +3.3V / SWDIO / SWCLK / GND (WCH-LinkE で書き込み) |
| J5 (未実装) | 2.54mm 3 ピン | 1 / 2 / 3 | UART TX (PA9) / RX (PA10) / GND (デバッグ用、USART1) |
| J6 (未実装) | 1.27mm 2 × 8 ピン | 下表 | 空きポート 14 本と +3.3V、GND |

J4〜J6 はパッドのみで、JLC では実装しません。使うときはピンヘッダを手はんだしてください。各端子の信号名は裏面シルクに記載しています (J6 は 1 番ピンの印のみ)。

J6 のピン配置 (選定理由は [ADR-0008](docs/adr/0008-io-breakout.md)):

| ピン | 信号 | ピン | 信号 |
|---|---|---|---|
| 1 | GND | 2 | PB7 |
| 3 | +3.3V | 4 | PB6 |
| 5 | PB1 | 6 | PB5 |
| 7 | PB0 | 8 | PA3 |
| 9 | PA8 | 10 | PA4 |
| 11 | PA15 | 12 | PA5 |
| 13 | PB3 | 14 | PA6 |
| 15 | PB4 | 16 | PA7 |

| 信号 | マイコンのピン | 機能 |
|---|---|---|
| R / G / B | PA0 / PA1 / PA2 | TIM2 CH1 / CH2 / CH3 |
| CAN RX / TX | PA11 / PA12 | CAN |
| SWDIO / SWCLK | PA13 / PA14 | 書き込み |
| UART TX / RX | PA9 / PA10 | USART1 (デバッグ用。ファームは 115200bps 8N1 で送信のみ) |
| 空きポート | PA3〜PA8、PA15、PB0、PB1、PB3〜PB7 | J6。ファームではプルアップ入力 |

ハーネス側の部品は [harness_parts.csv](hardware/fabrication/harness_parts.csv) を参照してください。VH のコンタクトは AWG22〜18 に対応します。5A には AWG18 を使ってください。圧着工具が必要です。

## CAN フレーム

11bit 標準 ID `0x7D0`、500kbit/s (`firmware/src/main.c` の定義で変更可)。ID は番号が大きいほど低優先なので、他の制御フレームを妨げません。

| バイト | 内容 |
|---|---|
| data[0..2] | R, G, B (0〜255)。2 乗カーブで PWM に変換 |
| data[3] | 点灯時間 × 100ms (最大 25.5 秒)。0 または省略で 500ms |

DLC が 3 未満のフレームは無視します。**CAN が途絶えると、この時間の経過後に消灯します。** 点灯を続けるには、500ms より短い周期 (例: 100ms) で送り続けてください。既定の 500ms はビルド時に `COLOR_TIMEOUT_MS` で変更できます。

## 基板アートワーク

画像はすべて部品面から見た向きです (裏面シルクの文字は裏から読むので鏡文字です)。

| 表面銅箔 | 裏面銅箔 |
|---|---|
|  |  |

| 表面シルク | 裏面シルク |
|---|---|
|  |  |

### 部品配置

## 3D ビュー

| 表面 | 裏面 |
|---|---|
|  |  |

Q1〜Q4、F1、J1〜J3 の 3D モデルは自作の簡易形状です。寸法と高さは JST のカタログ値に合わせています。

## 発注

JLCPCB に基板製造と部品実装 (Economic PCBA、片面) を頼む前提です。部品はすべて LCSC (JLC の部品在庫) の品番で指定しています。部品の選定理由は [ADR-0007](docs/adr/0007-jlc-assembly.md) を参照してください。

| データ | ファイル |
|---|---|
| ガーバー、ドリル | [gerber.zip](hardware/fabrication/gerber.zip) |
| JLC 用部品表 (LCSC 品番) | [jlc_bom.csv](hardware/fabrication/jlc_bom.csv) |
| JLC 用部品座標 | [jlc_cpl.csv](hardware/fabrication/jlc_cpl.csv) |
| 部品表 (メーカー型番付き) | [bom.csv](hardware/fabrication/bom.csv) |
| 部品座標 (KiCad 形式) | [positions.csv](hardware/fabrication/positions.csv) |
| 電線側の部品 (秋月) | [harness_parts.csv](hardware/fabrication/harness_parts.csv) |

| 製造仕様 | 値 |
|---|---|
| 層数、板厚、銅厚 | 2 層、1.6mm、1oz 以上 |
| 基板色 | 緑 |
| 最小配線幅、クリアランス | 0.2mm / 0.2mm (高電圧ネットは 0.6mm) |
| 最小穴径 | 0.3mm (ビア 0.7/0.3mm) |
| シルク文字 | 高さ 1.0mm 以上 |
| 実装 | 表面のみ。J1〜J3 は挿入部品 (JLC の手はんだ)。J4〜J6、JP1 は未実装 |

### 費用の見積り (5 枚、2026-11-07 時点)

JLC の部品検索と料金表から計算しました。$1 = ¥158 で換算しています。

| 費目 | 金額 |
|---|---|
| 部品 (LCSC、5 枚分 + JLC の予備分) | $31.9 |
| 拡張部品の追加料金 ($3.07 × 16 種類) | $49.1 |
| 実装の基本料 + ステンシル | $9.7 |
| はんだ付け (表面 790 点、挿入 45 点 + 手はんだ料) | $5.6 |
| 部品配置の確認 (任意) | $0.5 |
| **実装込みの小計** | **約 $97 (約 ¥15,300)** |
| 基板 5 枚 | 未確認 (JLC の即時見積りで確認) |
| 送料 | 未確認 (配送方法で変わる) |

追加料金は枚数によらず注文ごとにかかります。10 枚にすると実装込みで約 $121 (部品 $54.2) になり、1 枚あたりは下がります。

**発注前に確認してください。**

- ガーバーを JLC のビューアに通す (JLC の製造能力値を使ったルールチェックは、こちらで済ませて違反 0)。
- JLC のプレビューで部品の向きを確認する。KiCad の座標ファイルと JLC では、部品の回転の基準が違うことがある。
- 発注時の在庫を確認する。CH32V203K8T6 は在庫が少なめ (560 個)。

## 検証結果

| 検証 | 結果 |
|---|---|
| ERC | 違反 0 (警告を含む) |
| DRC (警告を含む、カスタムルール込み) | 違反 0、未接続 0 |
| JLCPCB の製造能力値を使った DRC | 違反 0 (最小値は配線幅 0.2mm、間隔 0.363mm、PTH の環状幅 0.2mm) |
| J3 のフットプリント | JST PA のカタログ値と照合済み |
| 回路図と基板の整合 | 不一致 0 |
| Q1〜Q4、F1 のランド | HYG080N10LS1C2 のパッケージ図、0451 系の推奨ランドと照合済み |
| ファームの PC テスト (`make test`) | 通過 |

実機の動作、温度、振動は未確認です。PlatformIO でのビルドと書き込みも未実行です。

配線幅は外層 1oz を前提に IPC-2221 で見積もると、5A 時の温度上昇は幅 2.5mm の電源配線で約 12°C、最も細い幅 2.2mm の LED 配線で約 15°C です。

## ファームウェア

```sh
cd firmware
make test            # PC 上で色の計算とログのバッファをテスト
make                 # riscv-none-elf-gcc でビルド
pio run -t upload    # WCH-LinkE で書き込み (未実行)
```

J5 に USB シリアル変換器をつなぐと、115200bps 8N1 でデバッグ出力が出ます。出力は 1 行に 1 イベントです。`make EXTRA_CFLAGS=-DDEBUG_UART=0` でビルドすると無効になります。

```
boot rst=por clk=hse can=ok id=7D0 kbps=500 timeout_ms=500
rgb FF8000 hold_ms=500     # 色が変わったときと、消灯から点いたとき
off timeout                # CAN が途絶えて消灯した
can errsr=00800033 passive # CAN のエラー状態が変わった
log dropped=12             # 送信が追いつかず捨てた文字数
```

## KiCad design hardware/rgb_led_controller.kicad_pcb

Parts:
C1: 10uF 100V; C_1210_3225Metric; MPN Murata GRM32EC72A106KE05L
C2: 0.1uF 100V; C_0603_1608Metric; MPN Samsung CL10B104KC8NNNC
C3, C4, C5: 1uF 50V; C_0603_1608Metric; MPN Samsung CL10A105KB8NNNC
C6, C7, C8, C9, C12, C13, C14: 0.1uF; C_0603_1608Metric; MPN YAGEO CC0603KRX7R9BB104
C10, C11: 15pF; C_0603_1608Metric; MPN Samsung CL10C150JB8NNNC
D1: SMBJ45CA; D_SMB; MPN SMBJ45CA
D2, D3: BZT52C15S; D_SOD-323; MPN BZT52C15S
F1: 10A 125V; Fuse_Littelfuse_NANO2_2410; MPN Littelfuse 0451010.MRL
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1: BATT_24V; JST_VH_B2P-VH_1x02_P3.96mm_Vertical; MPN JST B2P-VH(LF)(SN)
J2: LED_TAPE (24V/R/G/B); JST_VH_B4P-VH_1x04_P3.96mm_Vertical; MPN JST B4P-VH(LF)(SN)
J3: CAN; JST_PA_B03B-PASK; MPN JST B03B-PASK(LF)(SN)
J4: SWD; PinHeader_1x04_P1.27mm_Vertical_Pad1.05; MPN (未実装); not fitted
J5: UART; PinHeader_1x03_P2.54mm_Vertical; MPN (未実装); not fitted
J6: GPIO; PinHeader_2x08_P1.27mm_Vertical_Pad1.05; MPN (未実装); not fitted
JP1: TERM; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm; MPN (はんだブリッジ); not fitted
Q1, Q2, Q3, Q4: HYG080N10LS1C2; PDFN-8_5x6mm_P1.27mm; MPN HUAYI HYG080N10LS1C2
Q5: IRFR3910; TO-252-2; MPN Infineon IRFR3910TRPBF
R1, R2, R3, R4, R7, R8, R9, R13, R14, R15: 100k; R_0603_1608Metric; MPN UNI-ROYAL 0603WAF1003T5E
R5: 10k; R_0603_1608Metric; MPN UNI-ROYAL 0603WAF1002T5E
R6: 120; R_0603_1608Metric; MPN UNI-ROYAL 0603WAF1200T5E
R10, R11, R12: 470; R_0603_1608Metric; MPN UNI-ROYAL 0603WAF4700T5E
U1: CH32V203K8T6; LQFP-32_7x7mm_P0.8mm; MPN WCH CH32V203K8T6
U2: ATA6561; SOIC-8_3.9x4.9mm_P1.27mm; MPN Microchip ATA6561-GAQW-N
U3: 74VHCT04AFT; TSSOP-14_4.4x5mm_P0.65mm; MPN Toshiba 74VHCT04AFT
U4: CJ78L05; SOT-89-3; MPN JCET CJ78L05 (SOT-89)
U5: AP7333-33SAG; SOT-23; MPN Diodes AP7333-33SAG-7
Y1: 8MHz 10pF; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN YXC TAXM8M4RDBCCT2T

Connections:
+3V3: C5.1, C6.1, C7.1, C8.1, C13.1, J4.1, J6.3, U1.1 (VDD), U1.5 (VDDA), U1.17 (VDD), U2.5 (VIO), U5.2 (OUT)
+5V: C4.1, C12.1, C14.1, U2.3 (VCC), U3.14 (VCC), U4.1 (VOUT), U5.1 (IN)
+24V: C1.1, C2.1, D1.1 (A1), F1.2, J2.1, Q5.2 (D), R1.1, R3.1
/BOOT0: R5.1, U1.31 (BOOT0)
/CANH: J3.1, R6.1, U2.7 (CANH)
/CANL: J3.2, JP1.2 (B), U2.6 (CANL)
/CAN_RXD: U1.21 (PA11/CAN_RX), U2.4 (RXD)
/CAN_TERM: JP1.1 (A), R6.2
/CAN_TXD: U1.22 (PA12/CAN_TX), U2.1 (TXD)
/DRV_B: R12.1, U3.10 (5Y)
/DRV_G: R11.1, U3.8 (4Y)
/DRV_R: R10.1, U3.4 (2Y)
/GATE_B: Q4.4 (G), R12.2, R15.1
/GATE_G: Q3.4 (G), R11.2, R14.1
/GATE_R: Q2.4 (G), R10.2, R13.1
/GND_IN: D1.2 (A2), J1.2, Q1.5 (D)
/INV_B: U3.11 (5A), U3.12 (6Y)
/INV_G: U3.6 (3Y), U3.9 (4A)
/INV_R: U3.2 (1Y), U3.3 (2A)
/LED_B: J2.4, Q4.5 (D)
/LED_G: J2.3, Q3.5 (D)
/LED_R: J2.2, Q2.5 (D)
/NRST: C9.1, U1.4 (NRST)
/OSC_IN: C10.1, U1.2 (OSC_IN/PD0), Y1.1
/OSC_OUT: C11.1, U1.3 (OSC_OUT/PD1), Y1.3
/PA3: J6.8, U1.9 (PA3)
/PA4: J6.10, U1.10 (PA4)
/PA5: J6.12, U1.11 (PA5)
/PA6: J6.14, U1.12 (PA6)
/PA7: J6.16, U1.13 (PA7)
/PA8: J6.9, U1.18 (PA8)
/PA15: J6.11, U1.25 (PA15)
/PB0: J6.7, U1.14 (PB0)
/PB1: J6.5, U1.15 (PB1)
/PB3: J6.13, U1.26 (PB3)
/PB4: J6.15, U1.27 (PB4)
/PB5: J6.6, U1.28 (PB5)
/PB6: J6.4, U1.29 (PB6)
/PB7: J6.2, U1.30 (PB7)
/PWM_B: R9.1, U1.8 (PA2/TIM2_CH3), U3.13 (6A)
/PWM_G: R8.1, U1.7 (PA1/TIM2_CH2), U3.5 (3A)
/PWM_R: R7.1, U1.6 (PA0/TIM2_CH1), U3.1 (1A)
/Q1_BIAS: R1.2, R2.1
/Q1_G: D2.1 (K), Q1.4 (G), R2.2
/Q5_BIAS: R3.2, R4.1
/Q5_G: D3.1 (K), Q5.1 (G), R4.2
/SWCLK: J4.3, U1.24 (PA14/SWCLK)
/SWDIO: J4.2, U1.23 (PA13/SWDIO)
/UART_RX: J5.2, U1.20 (PA10)
/UART_TX: J5.1, U1.19 (PA9)
/VIN_RAW: F1.1, J1.1
/VPRE: C3.1, Q5.3 (S), U4.3 (VIN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, D2.2 (A), D3.2 (A), J3.3, J4.4, J5.3, J6.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.1 (S), Q2.2 (S), Q2.3 (S), Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S), R5.2, R7.2, R8.2, R9.2, R13.2, R14.2, R15.2, U1.16 (VSS), U1.32 (VSS), U2.2 (GND), U2.8 (STBY), U3.7 (GND), U4.2 (GND), U5.3 (GND), Y1.2 (G), Y1.4 (G)

Notes on the sheet:
1. 入力保護 (ヒューズ・TVS・ローサイド逆接保護)
Q1: 逆接時 OFF、ボディダイオードが阻止。R1+R2: 73V 時に 1608 の定格 50V を超えないよう直列。
2. 電源 (FET リニアプリレギュレータ → 5V → 3.3V)
VPRE ≈ 15V − VGS(Q5) ≈ 9.5〜13.3V。U4 の損失は最大 約0.5W。入力下限 約13V。
6. 取付穴・電源フラグ
3. マイコン (CH32V203K8T6, CAN 内蔵, 8MHz 水晶)
J4 (SWD, WCH-LinkE)、J5 (UART: USART1 PA9=TX / PA10=RX)、J6 (空きポート) は未実装パッド。
未使用ピンはプルアップ入力に設定。J1, J2 = JST VH / J3 = JST PA (ロック付、耐振動)。
4. CAN (ATA6561, 既定 500kbit/s, 11bit ID 0x7D0)
フレーム: ID 0x7D0, data[0..2]=R,G,B, data[3]=保持時間×100ms (省略/0 = 500ms)。途絶で消灯。
5. LED テープ駆動 (ローサイド N-MOS × 3, 5V ゲート)
U3 は 2 段直列で非反転。起動中は R7〜9 と R13〜15 で消灯。

Board: 2 copper layers, 51.0 x 42.6 mm, 55 parts (0 on the bottom side), 53 nets.

File hardware/fabrication/bom.csv:

"Reference","Value","Footprint","MPN","Vendor","Code","Qty","DNP"
"C1","10uF 100V","Capacitor_SMD:C_1210_3225Metric","Murata GRM32EC72A106KE05L","LCSC","C576517","1",""
"C2","0.1uF 100V","Capacitor_SMD:C_0603_1608Metric","Samsung CL10B104KC8NNNC","LCSC","C15725","1",""
"C3,C4,C5","1uF 50V","Capacitor_SMD:C_0603_1608Metric","Samsung CL10A105KB8NNNC","LCSC","C15849","3",""
"C6,C7,C8,C9,C12,C13,C14","0.1uF","Capacitor_SMD:C_0603_1608Metric","YAGEO CC0603KRX7R9BB104","LCSC","C14663","7",""
"C10,C11","15pF","Capacitor_SMD:C_0603_1608Metric","Samsung CL10C150JB8NNNC","LCSC","C1644","2",""
"D1","SMBJ45CA","Diode_SMD:D_SMB","SMBJ45CA","LCSC","C114006","1",""
"D2,D3","BZT52C15S","Diode_SMD:D_SOD-323","BZT52C15S","LCSC","C173448","2",""
"F1","10A 125V","vsi:Fuse_Littelfuse_NANO2_2410","Littelfuse 0451010.MRL","LCSC","C44479","1",""
"J1","BATT_24V","Connector_JST:JST_VH_B2P-VH_1x02_P3.96mm_Vertical","JST B2P-VH(LF)(SN)","LCSC","C160315","1",""
"J2","LED_TAPE (24V/R/G/B)","Connector_JST:JST_VH_B4P-VH_1x04_P3.96mm_Vertical","JST B4P-VH(LF)(SN)","LCSC","C160317","1",""
"J3","CAN","vsi:JST_PA_B03B-PASK","JST B03B-PASK(LF)(SN)","LCSC","C158048","1",""
"J4","SWD","vsi:PinHeader_1x04_P1.27mm_Vertical_Pad1.05","(未実装)","-","","1","DNP"
"J5","UART","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","(未実装)","-","","1","DNP"
"J6","GPIO","vsi:PinHeader_2x08_P1.27mm_Vertical_Pad1.05","(未実装)","-","","1","DNP"
"JP1","TERM","Jumper:SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm","(はんだブリッジ)","-","","1","DNP"
"Q1,Q2,Q3,Q4","HYG080N10LS1C2","vsi:PDFN-8_5x6mm_P1.27mm","HUAYI HYG080N10LS1C2","LCSC","C3011225","4",""
"Q5","IRFR3910","Package_TO_SOT_SMD:TO-252-2","Infineon IRFR3910TRPBF","LCSC","C148158","1",""
"R1,R2,R3,R4,R7,R8,R9,R13,R14,R15","100k","Resistor_SMD:R_0603_1608Metric","UNI-ROYAL 0603WAF1003T5E","LCSC","C25803","10",""
"R5","10k","Resistor_SMD:R_0603_1608Metric","UNI-ROYAL 0603WAF1002T5E","LCSC","C25804","1",""
"R6","120","Resistor_SMD:R_0603_1608Metric","UNI-ROYAL 0603WAF1200T5E","LCSC","C22787","1",""
"R10,R11,R12","470","Resistor_SMD:R_0603_1608Metric","UNI-ROYAL 0603WAF4700T5E","LCSC","C23179","3",""
"U1","CH32V203K8T6","Package_QFP:LQFP-32_7x7mm_P0.8mm","WCH CH32V203K8T6","LCSC","C5372188","1",""
"U2","ATA6561","Package_SO:SOIC-8_3.9x4.9mm_P1.27mm","Microchip ATA6561-GAQW-N","LCSC","C616016","1",""
"U3","74VHCT04AFT","Package_SO:TSSOP-14_4.4x5mm_P0.65mm","Toshiba 74VHCT04AFT","LCSC","C5381636","1",""
"U4","CJ78L05","Package_TO_SOT_SMD:SOT-89-3","JCET CJ78L05 (SOT-89)","LCSC","C2079","1",""
"U5","AP7333-33SAG","Package_TO_SOT_SMD:SOT-23","Diodes AP7333-33SAG-7","LCSC","C150746","1",""
"Y1","8MHz 10pF","Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm","YXC TAXM8M4RDBCCT2T","LCSC","C400090","1",""

## Code that names these connections

File firmware/src/main.c (part):

/*
 * RGB LED Controller Rev B ファームウェア (CH32V203K8T6)
 *
 * CAN で受けた色を TIM2 の PWM (PA0=R, PA1=G, PA2=B) に出す。
 * 割り込みは使わず、メインループでポーリングする。クロックは 8MHz 水晶を PLL なしで使う。
 * フレーム形式は docs/adr/0005-can-color-frame.md を参照。
 *
 * レジスタのオフセットとビットは WCH EVT (ch32v20x.h, ch32v20x_can.c) と照合した。
 *
 * デバッグ出力: USART1 (PA9=TX、J5) に 115200bps 8N1 で状態を出す。-DDEBUG_UART=0 で無効。
 * 出力は 1 行 1 イベントで、起動、色の変化、途絶による消灯、CAN エラー状態の変化、取りこぼし。
 */
#include <stdint.h>
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
    RCC_APB2PCENR |= (1u << 0) | (1u << 2) | (1u << 3); /* AFIO, GPIOA, GPIOB */

    /* 未使用ピンはプルアップ入力 (0x8)。PA0-2 は PWM 出力 (AF PP 10MHz = 0x9)。 */
    GPIO_OUTDR(GPIOA_BASE) = 0xFFF8u;
    GPIO_CFGLR(GPIOA_BASE) = 0x88888999u;

    /* PA11=CAN_RX (0x8)、PA12=CAN_TX (AF PP 50MHz = 0xB)。PA13/14 はデバッグ用に変更しない。
     * DEBUG_UART のとき PA9=USART1_TX (AF PP 50MHz = 0xB)。PA10 (RX) はプルアップ入力のまま。 */
    cfgh = GPIO_CFGHR(GPIOA_BASE);
    cfgh &= 0x0FF00000u;
    cfgh |= DEBUG_UART ? 0x800B88B8u : 0x800B8888u;
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